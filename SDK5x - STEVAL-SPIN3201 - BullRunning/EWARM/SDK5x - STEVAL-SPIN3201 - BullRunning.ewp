# IAR project SDK5x - STEVAL-SPIN3201 - BullRunning.ewp, settings and files
configuration SDK5x - STEVAL-SPIN3201 - BullRunning (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031C6 ST STM32F031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0; USE_HAL_DRIVER; STM32F031x6
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.2.0/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.2.0/MotorControl/MCSDK/MCLib/F0xx/Inc; ../MCSDK_v5.2.0/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.2.0/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDK5x - STEVAL-SPIN3201 - BullRunning.bin
  ILINK.IlinkOutputFile: SDK5x - STEVAL-SPIN3201 - BullRunning.out
  ILINK.IlinkIcfFile: stm32f031x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f031x6.s
  group Application/User
    ../Src/: main.c mc_api.c mc_config.c mc_parameters.c mc_tasks.c motor_control_protocol.c motorcontrol.c regular_conversion_manager.c stm32f0xx_hal_msp.c stm32f0xx_it.c stm32f0xx_mc_it.c ui_task.c user_interface.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Middlewares/MotorControl
    ../MCSDK_v5.2.0/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c mc_interface.c mc_irq_handler.c mc_math.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.2.0/MotorControl/MCSDK/UILibrary/Src/: frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
    ../MCSDK_v5.2.0/MotorControl/lib/: libmc-iar_M0.a
    ../MCSDK_v5.2.0/MotorControl/MCSDK/MCLib/F0xx/Src/: r3_f0xx_pwm_curr_fdbk.c
