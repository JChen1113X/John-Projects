<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SDK5x - STEVAL-SPIN3201 - BullRunning.ewp</path>
  </project>
  <batchBuild />
</workspace>
